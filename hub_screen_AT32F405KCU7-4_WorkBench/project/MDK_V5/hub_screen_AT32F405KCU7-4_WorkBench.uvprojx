# Keil uVision project hub_screen_AT32F405KCU7-4_WorkBench.uvprojx, settings and files
target hub_screen_AT32F405KCU7-4_WorkBench (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F405KCU7-4 ArteryTek
  pack: ArteryTek.AT32F402_405_DFP.2.1.1
  cpu: IRAM(0x20000000,0x19800) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hub_screen_AT32F405KCU7-4_WorkBench +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=3 wLevel=2
  c define: AT32F405KCU7_4,USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;../../middlewares/usb_drivers/inc;..\..\user_code;..\..\source
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x19800
  group user
    ../src/: at32f402_405_int.c at32f402_405_wk_config.c main.c wk_system.c usb_app.c wk_qspi.c wk_spi.c wk_usb.c wk_gpio.c wk_wdt.c wk_crc.c
  group firmware
    ../../libraries/drivers/src/: at32f402_405_crm.c at32f402_405_tmr.c at32f402_405_ertc.c at32f402_405_gpio.c at32f402_405_i2c.c at32f402_405_usart.c at32f402_405_pwc.c at32f402_405_adc.c at32f402_405_spi.c at32f402_405_dma.c at32f402_405_debug.c at32f402_405_flash.c at32f402_405_crc.c at32f402_405_wwdt.c at32f402_405_wdt.c at32f402_405_exint.c at32f402_405_misc.c at32f402_405_scfg.c at32f402_405_usb.c at32f402_405_acc.c at32f402_405_can.c at32f402_405_qspi.c
  group cmsis
    ./: startup_at32f402_405.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f402_405.c
  group middlewares/usb_driver
    ../../middlewares/usb_drivers/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
  group user_code
    ../../user_code/: lcd_spi.c lcd_spi.h at32_qspiflash.c at32_qspiflash.h ff_app.c ff_app.h Agreement.c Agreement.h
  group fatfs
    ../../source/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c
  group usbd_class
    ../src/: cdc_class.c cdc_desc.c
